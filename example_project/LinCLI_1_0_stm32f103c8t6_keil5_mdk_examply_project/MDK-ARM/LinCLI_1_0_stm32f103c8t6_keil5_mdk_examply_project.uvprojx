# Keil uVision project LinCLI_1_0_stm32f103c8t6_keil5_mdk_examply_project.uvprojx, settings and files
target LinCLI_1_0_stm32f103c8t6_keil5_mdk_examply_project (5060960::V5.06 update 7 (build 960)::.\v5Complier)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: LinCLI_1_0_stm32f103c8t6_keil5_mdk_examply_project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../../../cli/Inc;../../../include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\mdk_cli.sct
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group LinCLI
    ../../../cli/Src/: cli_cmd_line.c cli_io.c cli_logo.c cmd_dispose.c cli_candidate.c cli_completion.c cli_edit.c cli_history.c cli_parse.c cli_var.c
    ../../../init/: critical_default.c init_d.c pr_license.c scheduler.c section_markers.c
    ../../../lib/: cli_errno.c cli_mpool.c rbtree.c stateM.c tVector.c
    ../../../tests/: test_auto_cmd.c test_bool.c test_buf_insufficient.c test_callback.c test_conflicts.c test_double.c test_init_d.c test_int.c test_int_array.c test_key_interaction.c test_log.c test_required.c test_string.c test_with_buf.c test_led.c test_cli_var.c test_motor.c
software components: CMSIS:CORE 4.3.0
